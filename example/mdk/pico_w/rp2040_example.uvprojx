# Keil uVision project rp2040_example.uvprojx, settings and files
target Pico (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: RP2040:Core0 RPi
  pack: Keil.RP2040_DFP.9.9.9
  cpu: IRAM(0x20000000,0x00042000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rp2040_example
  AfterMake: $Stools\elf2uf2.exe "#L" ".\@L.uf2"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO_CYW43_ARCH_POLL
  c misc: -Omax
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x42000
  scatter file: .\RTE\Device\RP2040_Core0\rp2040.sct
  group APP
    ./: main.c
software components: CMSIS:CORE 6.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Pico Board 1.5.1, Device:Pico SDK 1.5.1, Device:Pico W SDK 1.5.1, Device:Startup 1.1.0
